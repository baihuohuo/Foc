# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\Systick;..\HARDWARE\FOC;..\HARDWARE\TIM;..\HARDWARE\ADC;..\HARDWARE\VOFA
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/KEY/: bsp_key.c bsp_key.h
    ../HARDWARE/Systick/: bsp_systick.c bsp_systick.h
    ../HARDWARE/TIM/: bsp_tim8_pwm.c bsp_tim8_pwm.h bsp_tim6_control.c bsp_tim6_control.h
    ../HARDWARE/ADC/: bsp_adc.c bsp_adc.h
    ../HARDWARE/VOFA/: bsp_vofa.c bsp_vofa.h
    ../HARDWARE/FOC/: foc_math.c foc_math.h foc_close_loop.c foc_close_loop.h foc_pi_controller.c foc_pi_controller.h foc_open_loop.c foc_open_loop.h
